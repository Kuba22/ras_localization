Commit message: Transform broadcasting from odometry node

File: visualize_model/robot_model.urdf (robot description, URDF)
Before this commit: robot robot, 1 links, 0 joints
Links:
- link base_link: geometry visual box size=0.25 0.25 0.11
